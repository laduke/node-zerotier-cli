## package/zerotier/Config.in
```kconfig
config BR2_PACKAGE_ZEROTIER
	bool "zerotier"
        help
          Virtual Networks

          http://foosoftware.org/libfoo/
```
